# Sierra toolchain

# Inherit from the external toolchain
SIERRA_VARIANT = "int"
require common/recipes/meta/meta-toolchain-swi-ext.bb
